# Repository DevLaTron/sd2snes

## KiCad design pcb/kicad/RevK/sd2snes.kicad_pcb

Notes on the sheet:
Changes from Rev.F / TODO: [x] Cleanup libraries and Schema, match Schema and PCB [x] Set HardwareID by adding GND to Pin 28 of MC [x] Add T922 OpAmp + Resistors to Audio section
sd2snes Mark II

Schematic: snesslot.sch, sd2snes Mark II

Parts:
C101, C102, C103, C104, C105, C106, C111, C112, C113, C114, C115, C116: 100n; SM0805_FIXEDMASK
C121, C122, C123, C124, C125, C126, C127, C128: 10p; SM0805_FIXEDMASK
FB103, FB104: FB; R_PACK_1206_2
J101: SNESCART_EXT
Q101: 2N2222A; SOT-23-EBC
R101: 270; SM0805_FIXEDMASK
R102: 100k; SM0805_FIXEDMASK
R103: 4k7; SM0805_FIXEDMASK
RA101, RA102, RA105, RA106, RA107, RA108, RA109, RA110, RA111, RA112, RA113, RA114: 100; R_PACK_1206_2
U101, U102, U103: 74ALVC164245DGG; TSSOP48

Connections:
+3.3V: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, U101.31, U101.42, U102.31, U102.42, U103.31, U103.42; also elsewhere on the board
+5VL: J101.27, J101.58; also elsewhere on the board
/SNES Slot/SNES_EXT_/IRQ: J101.18, RA105.5
/SNES Slot/SNES_EXT_/PARD: J101.4, RA111.8
/SNES Slot/SNES_EXT_/PAWR: J101.35, RA112.8
/SNES Slot/SNES_EXT_/RD: J101.23, RA105.6
/SNES Slot/SNES_EXT_/ROMSEL: J101.49, RA105.7
/SNES Slot/SNES_EXT_/WR: J101.54, RA102.3
/SNES Slot/SNES_EXT_A0: J101.17, RA106.5
/SNES Slot/SNES_EXT_A1: J101.16, RA106.7
/SNES Slot/SNES_EXT_A2: J101.15, RA107.5
/SNES Slot/SNES_EXT_A3: J101.14, RA107.7
/SNES Slot/SNES_EXT_A4: J101.13, RA108.5
/SNES Slot/SNES_EXT_A5: J101.12, RA108.7
/SNES Slot/SNES_EXT_A6: J101.11, RA109.5
/SNES Slot/SNES_EXT_A7: J101.10, RA109.7
/SNES Slot/SNES_EXT_A8: J101.9, RA110.5
/SNES Slot/SNES_EXT_A9: J101.8, RA110.7
/SNES Slot/SNES_EXT_A10: J101.7, RA111.5
/SNES Slot/SNES_EXT_A11: J101.6, RA111.7
/SNES Slot/SNES_EXT_A12: J101.37, RA111.6
/SNES Slot/SNES_EXT_A13: J101.38, RA110.8
/SNES Slot/SNES_EXT_A14: J101.39, RA110.6
/SNES Slot/SNES_EXT_A15: J101.40, RA109.8
/SNES Slot/SNES_EXT_A16: J101.41, RA109.6
/SNES Slot/SNES_EXT_A17: J101.42, RA108.8
/SNES Slot/SNES_EXT_A18: J101.43, RA108.6
/SNES Slot/SNES_EXT_A19: J101.44, RA107.8
/SNES Slot/SNES_EXT_A20: J101.45, RA107.6
/SNES Slot/SNES_EXT_A21: J101.46, RA106.8
/SNES Slot/SNES_EXT_A22: J101.47, RA106.6
/SNES Slot/SNES_EXT_A23: J101.48, RA105.8
/SNES Slot/SNES_EXT_CPU_CLK: J101.57, RA102.4
/SNES Slot/SNES_EXT_D0: FB104.3, J101.19
/SNES Slot/SNES_EXT_D1: FB104.1, J101.20
/SNES Slot/SNES_EXT_D2: FB103.3, J101.21
/SNES Slot/SNES_EXT_D3: FB103.1, J101.22
/SNES Slot/SNES_EXT_D4: FB104.4, J101.50
/SNES Slot/SNES_EXT_D5: FB104.2, J101.51
/SNES Slot/SNES_EXT_D6: FB103.4, J101.52
/SNES Slot/SNES_EXT_D7: FB103.2, J101.53
/SNES Slot/SNES_EXT_PA0: J101.28, RA102.1
/SNES Slot/SNES_EXT_PA1: J101.59, RA102.2
/SNES Slot/SNES_EXT_PA2: J101.29, RA101.3
/SNES Slot/SNES_EXT_PA3: J101.60, RA101.4
/SNES Slot/SNES_EXT_PA4: J101.30, RA101.1
/SNES Slot/SNES_EXT_PA5: J101.61, RA101.2
/SNES Slot/SNES_EXT_PA6: J101.3, RA112.7
/SNES Slot/SNES_EXT_PA7: J101.34, RA112.6
/SNES Slot/SNES_EXT_REFRESH: C126.1, J101.33, RA112.5
/SNES Slot/SNES_EXT_SYS_CLK: J101.1, R101.2, U103.23
AUDIO_L: J101.31; also elsewhere on the board
AUDIO_R: J101.62; also elsewhere on the board
CIC_CLK: J101.56; also elsewhere on the board
CIC_RESET: J101.25; also elsewhere on the board
DATABUS_/OE: U101.25; also elsewhere on the board
DATABUS_DIR: U101.24; also elsewhere on the board
EXT_CIC_DATA0: J101.55; also elsewhere on the board
EXT_CIC_DATA1: J101.24; also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, J101.5, J101.36, Q101.1 (E), R101.1, R102.2, U101.1, U101.4, U101.10, U101.15, U101.21, U101.28, U101.34, U101.39, U101.45, U101.48, U102.1, U102.4, U102.10, U102.15, U102.21, U102.24, U102.25, U102.28, U102.34, U102.39, U102.45, U102.48, U103.1, U103.4, U103.10, U103.15, U103.21, U103.24, U103.25, U103.28, U103.34, U103.39, U103.45, U103.48; also elsewhere on the board
unnamed: C121.1, RA102.5, U101.12
unnamed: C122.1, RA105.2, U102.3
unnamed: C123.1, Q101.3 (C), RA105.4
unnamed: C124.1, RA102.6, U101.11
unnamed: C125.1, RA105.3, U102.2
unnamed: C127.1, RA112.1, U103.17
unnamed: C128.1, RA111.1, U103.16
unnamed: FB103.5, U101.17
unnamed: FB103.6, U101.16
unnamed: FB103.7, U101.14
unnamed: FB103.8, U101.13
unnamed: FB104.5, U101.23
unnamed: FB104.6, U101.22
unnamed: FB104.7, U101.20
unnamed: FB104.8, U101.19
unnamed: Q101.2 (B), R102.1, R103.2
unnamed: RA101.5, U101.6
unnamed: RA101.6, U101.5
unnamed: RA101.7, U101.3
unnamed: RA101.8, U101.2
unnamed: RA102.7, U101.9
unnamed: RA102.8, U101.8
unnamed: RA105.1, U102.5
unnamed: RA106.1, U102.11
unnamed: RA106.2, U102.9
unnamed: RA106.3, U102.8
unnamed: RA106.4, U102.6
unnamed: RA107.1, U102.16
unnamed: RA107.2, U102.14
unnamed: RA107.3, U102.13
unnamed: RA107.4, U102.12
unnamed: RA108.1, U102.22
unnamed: RA108.2, U102.20
unnamed: RA108.3, U102.19
unnamed: RA108.4, U102.17
unnamed: RA109.1, U103.5
unnamed: RA109.2, U103.3
unnamed: RA109.3, U103.2
unnamed: RA109.4, U102.23
unnamed: RA110.1, U103.11
unnamed: RA110.2, U103.9
unnamed: RA110.3, U103.8
unnamed: RA110.4, U103.6
unnamed: RA111.2, U103.14
unnamed: RA111.3, U103.13
unnamed: RA111.4, U103.12
unnamed: RA112.2, U103.19
unnamed: RA112.3, U103.20
unnamed: RA112.4, U103.22
unnamed: RA113.1, U101.36
unnamed: RA113.2, U101.35
unnamed: RA113.3, U101.33
unnamed: RA113.4, U101.32
unnamed: RA114.1, U101.30
unnamed: RA114.2, U101.29
unnamed: RA114.3, U101.27
unnamed: RA114.4, U101.26
SNES_/PARD: U103.33; also elsewhere on the board
SNES_/PAWR: U103.32; also elsewhere on the board
SNES_/RD: U102.47; also elsewhere on the board
SNES_/RESET: J101.26; also elsewhere on the board
SNES_/ROMSEL: U102.46; also elsewhere on the board
SNES_/WR: U101.38; also elsewhere on the board
SNES_A0: U102.43; also elsewhere on the board
SNES_A1: U102.40; also elsewhere on the board
SNES_A2: U102.37; also elsewhere on the board
SNES_A3: U102.35; also elsewhere on the board
SNES_A4: U102.32; also elsewhere on the board
SNES_A5: U102.29; also elsewhere on the board
SNES_A6: U102.26; also elsewhere on the board
SNES_A7: U103.46; also elsewhere on the board
SNES_A8: U103.43; also elsewhere on the board
SNES_A9: U103.40; also elsewhere on the board
SNES_A10: U103.37; also elsewhere on the board
SNES_A11: U103.35; also elsewhere on the board
SNES_A12: U103.36; also elsewhere on the board
SNES_A13: U103.38; also elsewhere on the board
SNES_A14: U103.41; also elsewhere on the board
SNES_A15: U103.44; also elsewhere on the board
SNES_A16: U103.47; also elsewhere on the board
SNES_A17: U102.27; also elsewhere on the board
SNES_A18: U102.30; also elsewhere on the board
SNES_A19: U102.33; also elsewhere on the board
SNES_A20: U102.36; also elsewhere on the board
SNES_A21: U102.38; also elsewhere on the board
SNES_A22: U102.41; also elsewhere on the board
SNES_A23: U102.44; also elsewhere on the board
SNES_CPU_CLK: U101.37; also elsewhere on the board
SNES_D0: RA114.6; also elsewhere on the board
SNES_D1: RA114.8; also elsewhere on the board
SNES_D2: RA113.6; also elsewhere on the board
SNES_D3: RA113.8; also elsewhere on the board
SNES_D4: RA114.5; also elsewhere on the board
SNES_D5: RA114.7; also elsewhere on the board
SNES_D6: RA113.5; also elsewhere on the board
SNES_D7: RA113.7; also elsewhere on the board
SNES_IRQ_EN: R103.1; also elsewhere on the board
SNES_PA0: U101.41; also elsewhere on the board
SNES_PA1: U101.40; also elsewhere on the board
SNES_PA2: U101.44; also elsewhere on the board
SNES_PA3: U101.43; also elsewhere on the board
SNES_PA4: U101.47; also elsewhere on the board
SNES_PA5: U101.46; also elsewhere on the board
SNES_PA6: U103.30; also elsewhere on the board
SNES_PA7: U103.29; also elsewhere on the board
SNES_REFRESH: U103.27; also elsewhere on the board
SNES_SYS_CLK: U103.26; also elsewhere on the board

Notes on the sheet:
SNES bus, level shift

Schematic: memory.sch, sd2snes Mark II

Parts:
C501, C502, C511: 100n; SM0805_FIXEDMASK
D511: BAT54C; SOT-23
Q511: 2N2222A; SOT-23-EBC
R511: 20k; SM0805_FIXEDMASK
R512: 4k7; SM0805_FIXEDMASK
R513: 100k; SM0805_FIXEDMASK
U501: MT45W8MW16; VFBGA54
U511: CY62148EV30-ZSXI; TSOPII-32

Connections:
+1.8V: C502.1, U501.D6; also elsewhere on the board
+3.3V: C501.1, D511.2, R512.2, U501.E1; also elsewhere on the board
+BATT: D511.1; also elsewhere on the board
/Memory/RAM_/CE: Q511.3 (C), R511.2, U511.22
/Memory/SRAM_Vcc: C511.1, D511.3, R511.1, U511.32
GND: C501.2, C502.2, C511.2, Q511.1 (E), R513.2, U501.A6, U501.D1, U501.E6, U501.J2, U501.J3, U511.16; also elsewhere on the board
unnamed: Q511.2 (B), R512.1, R513.1
RAM_/OE: U511.24; also elsewhere on the board
RAM_/WE: U511.29; also elsewhere on the board
RAM_A0: U511.12; also elsewhere on the board
RAM_A1: U511.11; also elsewhere on the board
RAM_A2: U511.10; also elsewhere on the board
RAM_A3: U511.9; also elsewhere on the board
RAM_A4: U511.8; also elsewhere on the board
RAM_A5: U511.7; also elsewhere on the board
RAM_A6: U511.6; also elsewhere on the board
RAM_A7: U511.5; also elsewhere on the board
RAM_A8: U511.27; also elsewhere on the board
RAM_A9: U511.26; also elsewhere on the board
RAM_A10: U511.23; also elsewhere on the board
RAM_A11: U511.25; also elsewhere on the board
RAM_A12: U511.4; also elsewhere on the board
RAM_A13: U511.28; also elsewhere on the board
RAM_A14: U511.3; also elsewhere on the board
RAM_A15: U511.31; also elsewhere on the board
RAM_A16: U511.2; also elsewhere on the board
RAM_A17: U511.1; also elsewhere on the board
RAM_A18: U511.30; also elsewhere on the board
RAM_DQ0: U511.13; also elsewhere on the board
RAM_DQ1: U511.14; also elsewhere on the board
RAM_DQ2: U511.15; also elsewhere on the board
RAM_DQ3: U511.17; also elsewhere on the board
RAM_DQ4: U511.18; also elsewhere on the board
RAM_DQ5: U511.19; also elsewhere on the board
RAM_DQ6: U511.20; also elsewhere on the board
RAM_DQ7: U511.21; also elsewhere on the board
ROM_/CE: U501.B5; also elsewhere on the board
ROM_/LB: U501.A1; also elsewhere on the board
ROM_/OE: U501.A2; also elsewhere on the board
ROM_/UB: U501.B2; also elsewhere on the board
ROM_/WE: U501.G5; also elsewhere on the board
ROM_A0: U501.A3; also elsewhere on the board
ROM_A1: U501.A4; also elsewhere on the board
ROM_A2: U501.A5; also elsewhere on the board
ROM_A3: U501.B3; also elsewhere on the board
ROM_A4: U501.B4; also elsewhere on the board
ROM_A5: U501.C3; also elsewhere on the board
ROM_A6: U501.C4; also elsewhere on the board
ROM_A7: U501.D4; also elsewhere on the board
ROM_A8: U501.H2; also elsewhere on the board
ROM_A9: U501.H3; also elsewhere on the board
ROM_A10: U501.H4; also elsewhere on the board
ROM_A11: U501.H5; also elsewhere on the board
ROM_A12: U501.G3; also elsewhere on the board
ROM_A13: U501.G4; also elsewhere on the board
ROM_A14: U501.F3; also elsewhere on the board
ROM_A15: U501.F4; also elsewhere on the board
ROM_A16: U501.E4; also elsewhere on the board
ROM_A17: U501.D3; also elsewhere on the board
ROM_A18: U501.H1; also elsewhere on the board
ROM_A19: U501.G2; also elsewhere on the board
ROM_A20: U501.H6; also elsewhere on the board
ROM_A21: U501.E3; also elsewhere on the board
ROM_A22: U501.J4; also elsewhere on the board
ROM_DQ0: U501.B6; also elsewhere on the board
ROM_DQ1: U501.C5; also elsewhere on the board
ROM_DQ2: U501.C6; also elsewhere on the board
ROM_DQ3: U501.D5; also elsewhere on the board
ROM_DQ4: U501.E5; also elsewhere on the board
ROM_DQ5: U501.F5; also elsewhere on the board
ROM_DQ6: U501.F6; also elsewhere on the board
ROM_DQ7: U501.G6; also elsewhere on the board
ROM_DQ8: U501.B1; also elsewhere on the board
ROM_DQ9: U501.C1; also elsewhere on the board
ROM_DQ10: U501.C2; also elsewhere on the board
ROM_DQ11: U501.D2; also elsewhere on the board
ROM_DQ12: U501.E2; also elsewhere on the board
ROM_DQ13: U501.F2; also elsewhere on the board
ROM_DQ14: U501.F1; also elsewhere on the board
ROM_DQ15: U501.G1; also elsewhere on the board

Notes on the sheet:
Memory
SRAM battery power
Battery power OE switch
4Mbits 45ns SRAM (battery RAM + custom chip work RAM)
128Mbits 70ns PSRAM (ROM area)

Schematic: mcu.sch, sd2snes Mark II

Parts:
C401, C402, C403, C404, C405, C412: 100n; SM0805_FIXEDMASK
C406, C407: 33p; SM0805_FIXEDMASK
C408, C409: 10p; SM0805_FIXEDMASK
C411: 10u; SM0805_FIXEDMASK
D401: LED 2mA 1.9V, green; LED-3MM-FIXED
D402: LED 2mA 1.8V, yellow; LED-3MM-FIXED
D403: LED 2mA 1.7V, red; LED-3MM-FIXED
J411: Hirose DM3BT; Hirose_DM3BT-DSF-PEJS
J421: USB Micro-B SMT; USB_Micro-B_Wuerth-629105150521
JP401: JUMPER; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP402: JUMPER; SM0805_FIXEDMASK
P401: CONN_7X2; pin_array_7x2
P402, P403: CONN_2; PinHeader_1x02_P2.54mm_Vertical
P404: CONN_3X2; PinHeader_2x03_P2.54mm_Vertical
R401, R402, R403: 680; SM0805_FIXEDMASK
R404, R407: 10k; SM0805_FIXEDMASK
R405, R406: 100; SM0805_FIXEDMASK
R421, R422: 33; SM0805_FIXEDMASK
R423: 1.5k; SM0805_FIXEDMASK
U401: LPC1754; LQFP80-.5
X401: 12MHz; HC49US
X402: 32.768kHz; XTAL_SMD_05019

Connections:
+3.3V: C401.1, C402.1, C403.1, C404.1, C411.1, C412.1, D401.1 (A), D402.1 (A), D403.1 (A), J411.4, P401.1, R404.2, R407.2, U401.8, U401.10, U401.21, U401.34, U401.42, U401.56, U401.67, U401.77; also elsewhere on the board
+BATT: U401.16; also elsewhere on the board
/RESET: C405.1, P401.5, P402.2 (PM), R404.1, U401.14
/TRST: P401.9, U401.4
/USEBATT: JP402.2, U401.70
CCLK: R405.1; also elsewhere on the board
CIC_DATA0: U401.38; also elsewhere on the board
CIC_DATA1: U401.37; also elsewhere on the board
CIC_MCLR: JP401.2; also elsewhere on the board
CIC_STATUS: U401.36; also elsewhere on the board
DAC_/DEM: U401.30; also elsewhere on the board
DIN+MCU_/OVR: U401.50; also elsewhere on the board
DONE: U401.44; also elsewhere on the board
EXT_TDI: P401.11, U401.2
EXT_TDO: P401.12, U401.1
FPGA_CLK: U401.39; also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C411.2, C412.2, J411.6, J411.11, J421.5, J421.6, JP402.1, P401.3, P402.1, P403.1, U401.9, U401.12, U401.24, U401.28, U401.33, U401.43, U401.57, U401.66, U401.78; also elsewhere on the board
INIT_B+MCU_IRQ: U401.49; also elsewhere on the board
MCU_SPARE: P404.4, U401.73
MCU_SPI_MISO: U401.46; also elsewhere on the board
MCU_SPI_MOSI: U401.45; also elsewhere on the board
MCU_SPI_SCK: U401.47; also elsewhere on the board
MCU_SPI_SS: U401.48; also elsewhere on the board
unnamed: C406.1, U401.19, X401.1
unnamed: C407.1, U401.20, X401.2
unnamed: C408.1, U401.13, X402.1
unnamed: C409.1, U401.15, X402.2
unnamed: D401.2 (K), R401.2
unnamed: D402.2 (K), R402.2
unnamed: D403.2 (K), R403.2
unnamed: J411.9, U401.62
unnamed: J421.1, U401.18
unnamed: J421.2, R422.1
unnamed: J421.3, R421.1, R423.1
unnamed: JP401.1, U401.31
unnamed: P403.2 (PM), U401.25
unnamed: R401.1, U401.54
unnamed: R402.1, U401.53
unnamed: R403.1, U401.29
unnamed: R405.2, U401.40
unnamed: R406.1, U401.69
unnamed: R421.2, U401.22
unnamed: R422.2, U401.23
P1_CLK: P404.2, U401.75
P1_D0: P404.1, U401.76
P2.10: P401.4, R407.1, U401.41
P2_CLK: P404.5, U401.72
P2_D0: P404.6, U401.71
PROG_B: R406.2; also elsewhere on the board
P_LATCH: P404.3, U401.74
RX0: P401.13, U401.80
RX3: P401.7, U401.6
SD_CLK: J411.5, U401.63; also elsewhere on the board
SD_CMD: J411.3, U401.61; also elsewhere on the board
SD_DAT0: J411.7, U401.60; also elsewhere on the board
SD_DAT1: J411.8, U401.59; also elsewhere on the board
SD_DAT2: J411.1, U401.58; also elsewhere on the board
SD_DAT3: J411.2, U401.55; also elsewhere on the board
SNES_/RESET: U401.32; also elsewhere on the board
TCK: P401.8, U401.5
TMS: P401.10, U401.3
TX0: P401.14, U401.79
TX3: P401.6, U401.7
USB_SWCONN: R423.2, U401.65

Notes on the sheet:
open in case of in-circuit PIC programming
or 3000mcd LEDs (10k for R401-403)
Freeze button
MCU, SD, debug
Reset button
2mA low current LEDs

Schematic: pwr_misc.sch, sd2snes Mark II, Rev. K

Parts:
BT351: Keystone 1059 / KZH20PCB; BT_KEYSTONE_1059_20MM
C301, C303, C304, C311, C312, C321, C322: 4.7u; SM0805_FIXEDMASK
C302: 10n; SM0805_FIXEDMASK
C331, C341, C343: 100n; SM0805_FIXEDMASK
C332, C333: 100p; SM0805_FIXEDMASK
C342: 1u; SM0805_FIXEDMASK
C344, C345: 10u; SM0805_FIXEDMASK
C391: 100u; SM1210L
FB341: FILTER; SM0805_FIXEDMASK
JP341: FB 0603; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L301, L302: 1uH; SM1210L; PartNo LQH32PN1R0NN0L
L391: 10uH; SM1210L
Q301: IRLML6402PbF; SOT-23
R230, R231: 10; SM0805_FIXEDMASK
R301: 20k; SM0805_FIXEDMASK
R331, R332, R333: 680; SM0805_FIXEDMASK
U230: TS9222; TSSOP-8_4.4x3mm_P0.65mm
U301: MIC23250-S4YMT; QFN10-2x2
U311: MCP1824-1802E/OT; SOT23-5_LARGEPADS
U321: MCP1824-2502E/OT; SOT23-5_LARGEPADS
U331: PIC12F629-I/P; DIP-8_W7.62mm
U341: CS4344; TSSOP10

Connections:
+1.2V: C303.1, L301.1, U301.1; also elsewhere on the board
+1.8V: C312.1, U311.5; also elsewhere on the board
+2.5V: C322.1, U321.5; also elsewhere on the board
+3.3V: C304.1, C311.1, C321.1, FB341.2, L302.2, U301.10, U311.1, U311.3, U321.1, U321.3; also elsewhere on the board
+3.3VDAC: C341.1, C342.1, FB341.1, U230.8, U341.9
+5VL: C391.1, L391.2; also elsewhere on the board
+BATT: BT351.1 (+); also elsewhere on the board
/Power Supply / Misc./REG_SW1: L301.2, U301.4
/Power Supply / Misc./REG_SW2: L302.1, U301.7
AUDIO_L: R231.2; also elsewhere on the board
AUDIO_R: R230.2; also elsewhere on the board
CIC_CLK: R331.2; also elsewhere on the board
CIC_DATA0: C332.1, R332.1, U331.7 (GP0); also elsewhere on the board
CIC_DATA1: C333.1, R333.2, U331.6 (GP1); also elsewhere on the board
CIC_MCLR: U331.4 (GP3/MCLR); also elsewhere on the board
CIC_RESET: U331.5 (GP2); also elsewhere on the board
CIC_STATUS: U331.3 (GP4/OSC2); also elsewhere on the board
DAC_/DEM: U341.2; also elsewhere on the board
DAC_LRCK: U341.3; also elsewhere on the board
DAC_MCLK: U341.4; also elsewhere on the board
DAC_SDIN: U341.1; also elsewhere on the board
EXT_CIC_DATA0: R332.2; also elsewhere on the board
EXT_CIC_DATA1: R333.1; also elsewhere on the board
GND: BT351.2 (-), C301.2, C302.2, C303.2, C304.2, C311.2, C312.2, C321.2, C322.2, C331.2, C332.2, C333.2, C391.2, JP341.2, R301.1, U301.3, U301.5, U311.2, U321.2, U331.8 (VSS); also elsewhere on the board
unnamed: C343.1, C344.1, U341.5
unnamed: C345.1, U341.6
unnamed: L391.1, Q301.3
unnamed: Q301.1, R301.2
unnamed: R230.1, U230.6, U230.7
unnamed: R231.1, U230.1, U230.2
unnamed: R331.1, U331.2 (GP5/OSC1)
unnamed: U230.3, U341.7
unnamed: U230.5, U341.10

Notes on the sheet:
Stuff with 0603 ferrite bead
Power, DAC, CIC, Batt
inverse polarity protection
Battery (SRAM + RTC)
2.5V LDO
1.8V LDO
3.3V + 1.2V Step-Down
Audio DAC
Power Supply
SuperCIC Key

Parts:
C201, C202, C203, C204, C205, C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C221, C222, C223, C224, C231, C232, C233, C234: 100n; SM0805_FIXEDMASK
P113: CONN_1; PAD_1x1mm
U201: XC3S400-PQ208; PQFP208_ALTPADS

Connections:
+1.2V: C221.1, C222.1, C223.1, C224.1, U201.70 (VCCINT), U201.88 (VCCINT), U201.174 (VCCINT), U201.192 (VCCINT); also elsewhere on the board
+2.5V: C210.1, C211.1, C212.1, C213.1, C214.1, C215.1, U201.17 (VCCAUX), U201.38 (VCCAUX), U201.69 (VCCAUX), U201.89 (VCCAUX), U201.121 (VCCAUX), U201.142 (VCCAUX), U201.173 (VCCAUX), U201.193 (VCCAUX); also elsewhere on the board
+3.3V: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C231.1, C232.1, C233.1, C234.1, U201.6 (VCCO_7), U201.23 (VCCO_7), U201.32 (VCCO_6), U201.49 (VCCO_6), U201.60 (VCCO_5), U201.73 (VCCO_5), U201.84 (VCCO_4), U201.98 (VCCO_4), U201.110 (VCCO_3), U201.127 (VCCO_3), U201.136 (VCCO_2), U201.153 (VCCO_2), U201.164 (VCCO_1), U201.177 (VCCO_1), U201.188 (VCCO_0), U201.201 (VCCO_0); also elsewhere on the board
CCLK: U201.104 (CCLK); also elsewhere on the board
DAC_LRCK: U201.77 (IO_L32N_5/GCLK3); also elsewhere on the board
DAC_MCLK: U201.76 (IO_L32P_5/GCLK2); also elsewhere on the board
DAC_SDIN: U201.78 (IO/VREF_5); also elsewhere on the board
DATABUS_/OE: U201.109 (IO_L17N_3); also elsewhere on the board
DATABUS_DIR: U201.111 (IO_L19P_3); also elsewhere on the board
DIN+MCU_/OVR: U201.92 (IO_L27N_4/DIN/D0); also elsewhere on the board
DONE: U201.103 (DONE); also elsewhere on the board
FPGA_CLK: U201.80 (IO_L32N_4/GCLK1); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C221.2, C222.2, C223.2, C224.2, C231.2, C232.2, C233.2, C234.2, U201.1 (GND), U201.8 (GND), U201.14 (GND), U201.25 (GND), U201.30 (GND), U201.41 (GND), U201.47 (GND), U201.53 (GND), U201.59 (GND), U201.66 (GND), U201.75 (GND), U201.82 (GND), U201.91 (GND), U201.99 (GND), U201.105 (GND), U201.112 (GND), U201.118 (GND), U201.129 (GND), U201.134 (GND), U201.145 (GND), U201.151 (GND), U201.157 (GND), U201.163 (GND), U201.170 (GND), U201.179 (GND), U201.186 (GND), U201.195 (GND), U201.202 (GND), U201.206 (HSWAP_EN); also elsewhere on the board
INIT_B+MCU_IRQ: U201.83 (IO_L31N_4/INIT_B); also elsewhere on the board
MCU_SPI_MISO: U201.72 (IO_L31P_5/D5); also elsewhere on the board
MCU_SPI_MOSI: U201.74 (IO_L31N_5/D4); also elsewhere on the board
MCU_SPI_SCK: U201.71 (IO); also elsewhere on the board
MCU_SPI_SS: U201.68 (IO_L28N_5/D6); also elsewhere on the board
unnamed: P113.1, U201.113 (IO_L19N_3)
PROG_B: U201.207 (PROG_B); also elsewhere on the board
RAM_/OE: U201.36 (IO_L23P_6); also elsewhere on the board
RAM_/WE: U201.50 (IO/VREF_6); also elsewhere on the board
RAM_A0: U201.28 (IO_L40P_6/VREF_6); also elsewhere on the board
RAM_A1: U201.31 (IO_L39P_6); also elsewhere on the board
RAM_A2: U201.33 (IO_L39N_6); also elsewhere on the board
RAM_A3: U201.35 (IO_L24N_6/VREF_6); also elsewhere on the board
RAM_A4: U201.37 (IO_L23N_6); also elsewhere on the board
RAM_A5: U201.40 (IO_L22N_6); also elsewhere on the board
RAM_A6: U201.43 (IO_L21N_6); also elsewhere on the board
RAM_A7: U201.45 (IO_L20N_6); also elsewhere on the board
RAM_A8: U201.44 (IO_L20P_6); also elsewhere on the board
RAM_A9: U201.42 (IO_L21P_6); also elsewhere on the board
RAM_A10: U201.34 (IO_L24P_6); also elsewhere on the board
RAM_A11: U201.39 (IO_L22P_6); also elsewhere on the board
RAM_A12: U201.48 (IO_L19N_6); also elsewhere on the board
RAM_A13: U201.46 (IO_L19P_6); also elsewhere on the board
RAM_A14: U201.51 (IO_L01P_6/VRN_6); also elsewhere on the board
RAM_A15: U201.58 (IO_L01N_5/RDWR_B); also elsewhere on the board
RAM_A16: U201.57 (IO_L01P_5/CS_B); also elsewhere on the board
RAM_A17: U201.61 (IO_L10P_5/VRN_5); also elsewhere on the board
RAM_A18: U201.52 (IO_L01N_6/VRP_6); also elsewhere on the board
RAM_DQ0: U201.26 (IO_L40P_7); also elsewhere on the board
RAM_DQ1: U201.22 (IO_L39P_7); also elsewhere on the board
RAM_DQ2: U201.20 (IO_L24P_7); also elsewhere on the board
RAM_DQ3: U201.19 (IO_L23N_7); also elsewhere on the board
RAM_DQ4: U201.21 (IO_L24N_7); also elsewhere on the board
RAM_DQ5: U201.24 (IO_L39N_7); also elsewhere on the board
RAM_DQ6: U201.27 (IO_L40N_7/VREF_7); also elsewhere on the board
RAM_DQ7: U201.29 (IO_L40N_6); also elsewhere on the board
ROM_/CE: U201.172 (IO_L28N_1); also elsewhere on the board
ROM_/LB: U201.156 (IO_L01N_2/VRP_2); also elsewhere on the board
ROM_/OE: U201.162 (IO_L01N_1/VRP_1); also elsewhere on the board
ROM_/UB: U201.161 (IO_L01P_1/VRN_1); also elsewhere on the board
ROM_/WE: U201.190 (IO_L30P_0); also elsewhere on the board
ROM_A0: U201.166 (IO_L10N_1/VREF_1); also elsewhere on the board
ROM_A1: U201.168 (IO_L27P_1); also elsewhere on the board
ROM_A2: U201.171 (IO_L28P_1); also elsewhere on the board
ROM_A3: U201.165 (IO_L10P_1); also elsewhere on the board
ROM_A4: U201.169 (IO_L27N_1); also elsewhere on the board
ROM_A5: U201.18 (IO_L23P_7); also elsewhere on the board
ROM_A6: U201.175 (IO); also elsewhere on the board
ROM_A7: U201.167 (IO); also elsewhere on the board
ROM_A8: U201.205 (IO/VREF_0); also elsewhere on the board
ROM_A9: U201.204 (IO_L01N_0/VRP_0); also elsewhere on the board
ROM_A10: U201.197 (IO); also elsewhere on the board
ROM_A11: U201.196 (IO_L27N_0); also elsewhere on the board
ROM_A12: U201.2 (IO_L01P_7/VRN_7); also elsewhere on the board
ROM_A13: U201.194 (IO_L27P_0); also elsewhere on the board
ROM_A14: U201.200 (IO/VREF_0); also elsewhere on the board
ROM_A15: U201.184 (IO_L32N_0/GCLK7); also elsewhere on the board
ROM_A16: U201.199 (IO_L25N_0); also elsewhere on the board
ROM_A17: U201.11 (IO_L20N_7); also elsewhere on the board
ROM_A18: U201.3 (IO_L01N_7/VRP_7); also elsewhere on the board
ROM_A19: U201.4 (IO_L16P_7/VREF_7); also elsewhere on the board
ROM_A20: U201.191 (IO_L30N_0); also elsewhere on the board
ROM_A21: U201.203 (IO_L01P_0/VRN_0); also elsewhere on the board
ROM_A22: U201.198 (IO_L25P_0); also elsewhere on the board
ROM_DQ0: U201.176 (IO_L31P_1); also elsewhere on the board
ROM_DQ1: U201.178 (IO_L31N_1/VREF_1); also elsewhere on the board
ROM_DQ2: U201.181 (IO_L32N_1GCLK5); also elsewhere on the board
ROM_DQ3: U201.182 (IO); also elsewhere on the board
ROM_DQ4: U201.183 (IO_L32P_0/GCLK6); also elsewhere on the board
ROM_DQ5: U201.187 (IO_L31N_0); also elsewhere on the board
ROM_DQ6: U201.185 (IO_L31P_0/VREF_0); also elsewhere on the board
ROM_DQ7: U201.189 (IO); also elsewhere on the board
ROM_DQ8: U201.16 (IO_L22N_7); also elsewhere on the board
ROM_DQ9: U201.13 (IO_L21N_7); also elsewhere on the board
ROM_DQ10: U201.15 (IO_L22P_7); also elsewhere on the board
ROM_DQ11: U201.12 (IO_L21P_7); also elsewhere on the board
ROM_DQ12: U201.10 (IO_L20P_7); also elsewhere on the board
ROM_DQ13: U201.7 (IO_L19P_7); also elsewhere on the board
ROM_DQ14: U201.9 (IO_L19N_7/VREF_7); also elsewhere on the board
ROM_DQ15: U201.5 (IO_L16N_7); also elsewhere on the board
SD_CLK: U201.64 (IO_L27P_5); also elsewhere on the board
SD_CMD: U201.67 (IO_L28P_5/D7); also elsewhere on the board
SD_DAT0: U201.65 (IO_L27N_5/VREF_5); also elsewhere on the board
SD_DAT1: U201.79 (IO_L32P_4/GCLK0); also elsewhere on the board
SD_DAT2: U201.62 (IO_L10N_5/VRP_5); also elsewhere on the board
SD_DAT3: U201.63 (IO); also elsewhere on the board
SNES_/PARD: U201.149 (IO_L20N_2); also elsewhere on the board
SNES_/PAWR: U201.150 (IO_L19P_2); also elsewhere on the board
SNES_/RD: U201.115 (IO_L20N_3); also elsewhere on the board
SNES_/ROMSEL: U201.116 (IO_L21P_3); also elsewhere on the board
SNES_/WR: U201.94 (IO_L25P_4); also elsewhere on the board
SNES_A0: U201.119 (IO_L22P_3); also elsewhere on the board
SNES_A1: U201.122 (IO_L23P_3/VREF_3); also elsewhere on the board
SNES_A2: U201.124 (IO_L24P_3); also elsewhere on the board
SNES_A3: U201.126 (IO_L39P_3); also elsewhere on the board
SNES_A4: U201.130 (IO_L40P_3); also elsewhere on the board
SNES_A5: U201.132 (IO_L40P_2/VREF_2); also elsewhere on the board
SNES_A6: U201.135 (IO_L39P_2); also elsewhere on the board
SNES_A7: U201.138 (IO_L24P_2); also elsewhere on the board
SNES_A8: U201.140 (IO_L23P_2); also elsewhere on the board
SNES_A9: U201.143 (IO_L22P_2); also elsewhere on the board
SNES_A10: U201.146 (IO_L21P_2); also elsewhere on the board
SNES_A11: U201.148 (IO_L20P_2); also elsewhere on the board
SNES_A12: U201.147 (IO-L21N_2); also elsewhere on the board
SNES_A13: U201.144 (IO_L22N_2); also elsewhere on the board
SNES_A14: U201.141 (IO_L23N_2/VREF_2); also elsewhere on the board
SNES_A15: U201.139 (IO_L24N_2); also elsewhere on the board
SNES_A16: U201.137 (IO_L39N_2); also elsewhere on the board
SNES_A17: U201.133 (IO_L40N_2); also elsewhere on the board
SNES_A18: U201.131 (IO_L40N_3/VREF_3); also elsewhere on the board
SNES_A19: U201.128 (IO_L39N_3); also elsewhere on the board
SNES_A20: U201.125 (IO_L24N_3); also elsewhere on the board
SNES_A21: U201.123 (IO_L23N_3); also elsewhere on the board
SNES_A22: U201.120 (IO_L22N_3); also elsewhere on the board
SNES_A23: U201.117 (IO_L21N_3); also elsewhere on the board
SNES_CPU_CLK: U201.95 (IO_L25N_4); also elsewhere on the board
SNES_D0: U201.107 (IO_L01N_3/VRP_3); also elsewhere on the board
SNES_D1: U201.102 (IO/VREF_4); also elsewhere on the board
SNES_D2: U201.100 (IO_L01P_4/VRN_4); also elsewhere on the board
SNES_D3: U201.96 (IO/VREF_4); also elsewhere on the board
SNES_D4: U201.108 (IO_L17P_3/VREF_3); also elsewhere on the board
SNES_D5: U201.106 (IO_L01P_3/VRN_3); also elsewhere on the board
SNES_D6: U201.101 (IO_L01N_4/VRP_4); also elsewhere on the board
SNES_D7: U201.97 (IO); also elsewhere on the board
SNES_IRQ_EN: U201.114 (IO_L20P_3); also elsewhere on the board
SNES_PA0: U201.90 (IO_L27P_4/D1); also elsewhere on the board
SNES_PA1: U201.93 (IO); also elsewhere on the board
SNES_PA2: U201.86 (IO_L30P_4/D3); also elsewhere on the board
SNES_PA3: U201.87 (IO_L30N_4/D2); also elsewhere on the board
SNES_PA4: U201.81 (IO_L31P_4/DOUT/BUSY); also elsewhere on the board
SNES_PA5: U201.85 (IO/VREF_4); also elsewhere on the board
SNES_PA6: U201.152 (IO_L19N_2); also elsewhere on the board
SNES_PA7: U201.154 (IO/VREF_2); also elsewhere on the board
SNES_REFRESH: U201.155 (IO_L01P_2/VRN_2); also elsewhere on the board
SNES_SYS_CLK: U201.180 (IO_L32P_1/GCLK4); also elsewhere on the board

Notes on the sheet:
FPGA
SNES A+B bus
70ns PSRAM bus
45ns SRAM bus
SD bus; shared with MCU
SPI (MCU interface)
DAC
JTAG

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

Notices in the files:
pcb/kicad/RevK/sd2snes.kicad_pcb:
©2009 - 2019 ikari_01
